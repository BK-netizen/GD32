# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32H757ZM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.2.0
  cpu: IRAM(0x24000000,0x000E0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00010000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\Firmware\CMSIS;..\..\..\Firmware\GD32H7xx_standard_peripheral\Include;..\..\..\Software_Driver;..\..\..\Software_Driver\MCU_Driver;..\..\..\Software_Driver\BSP_Driver;..\..\..\Firmware\CMSIS\GD\GD32H7xx\Include;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: ..\..\..\Software_Driver\keil_link_H7.sct
  group Application
    ../: main.c gd32h7xx_interrupt.c
  group Firmware
    ../../../Firmware/GD32H7xx_standard_peripheral/Source/: gd32h7xx_adc.c gd32h7xx_can.c gd32h7xx_cau.c gd32h7xx_cau_aes.c gd32h7xx_cau_des.c gd32h7xx_cau_tdes.c gd32h7xx_cmp.c gd32h7xx_cpdm.c gd32h7xx_crc.c gd32h7xx_ctc.c gd32h7xx_dac.c gd32h7xx_dbg.c gd32h7xx_dci.c gd32h7xx_dma.c gd32h7xx_edout.c gd32h7xx_efuse.c gd32h7xx_enet.c gd32h7xx_exmc.c gd32h7xx_exti.c gd32h7xx_fac.c gd32h7xx_fmc.c gd32h7xx_fwdgt.c gd32h7xx_gpio.c gd32h7xx_hau.c gd32h7xx_hau_sha_md5.c gd32h7xx_hpdf.c gd32h7xx_hwsem.c gd32h7xx_i2c.c gd32h7xx_ipa.c gd32h7xx_lpdts.c gd32h7xx_mdio.c gd32h7xx_mdma.c gd32h7xx_misc.c gd32h7xx_ospi.c gd32h7xx_ospim.c gd32h7xx_pmu.c gd32h7xx_rameccmu.c gd32h7xx_rcu.c gd32h7xx_rspdif.c gd32h7xx_rtc.c gd32h7xx_rtdec.c gd32h7xx_sai.c gd32h7xx_sdio.c gd32h7xx_spi.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_tli.c gd32h7xx_tmu.c gd32h7xx_trigsel.c gd32h7xx_trng.c gd32h7xx_usart.c gd32h7xx_vref.c gd32h7xx_wwdgt.c
  group CMSIS
    ../../../Firmware/CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group BSP_Driver
    ../../../Software_Driver/BSP_Driver/: bsp_uart.c bsp_led.c bsp_adc.c bsp_beep.c bsp_dht11.c bsp_eeprom.c bsp_key.c bsp_oled.c bsp_rgb_pwm.c bsp_sdcard.c bsp_spi.c bsp_spi_nand.c bsp_spi_nor.c bsp_timer.c bsp_touch_panel.c bsp_touch_cap.c bsp_ov7670.c bsp_8080_lcd.c bsp_rgb_lcd.c bsp_lcd_font.c bsp_software_i2c.c
    ../../../Software_Driver/: gd_log.c
  group MCU_Driver
    ../../../Software_Driver/: driver_public.c
    ../../../Software_Driver/MCU_Driver/: driver_gpio.c driver_dma.c driver_uart.c driver_adc.c driver_exmc.c driver_fmc.c driver_i2c.c driver_spi.c driver_timer.c driver_wdog.c
  group Startup
    ../../../Firmware/CMSIS/GD/GD32H7xx/Source/ARM/: startup_gd32h7xx.s
  group readme
    ../: readme.txt
software components: CMSIS:CORE 5.4.0
